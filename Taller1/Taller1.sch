v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 50 -60 50 30 {}
L 4 50 -60 420 -60 {}
L 4 420 -60 420 30 {}
L 4 420 30 420 50 {}
L 4 420 50 420 60 {}
L 4 50 60 420 60 {}
L 4 50 30 50 60 {}
L 4 -415 -60 -415 30 {}
L 4 -415 -60 -45 -60 {}
L 4 -45 -60 -45 30 {}
L 4 -45 30 -45 50 {}
L 4 -45 50 -45 60 {}
L 4 -415 60 -45 60 {}
L 4 -415 30 -415 60 {}
T {Simulaciones de compuerta NOT} 60 -120 0 0 0.4 0.4 {}
T {Simulaciones de Transistores
} -415 -120 0 0 0.4 0.4 {}
C {/workspaces/usm-vlsi-tools/shared_xserver/Talleres/Taller1/Resuelto/Test_inv_hv.sym} 230 -30 0 0 {name=x1}
C {/workspaces/usm-vlsi-tools/shared_xserver/Talleres/Taller1/Resuelto/Test_inv_lv.sym} 230 20 0 0 {name=x2}
C {title.sym} -480 160 0 0 {name=l1 author="Taller 1 ChipUSM"}
C {/workspaces/usm-vlsi-tools/shared_xserver/Talleres/Taller1/Resuelto/Nmoslv_test.sym} -235 -30 0 0 {name=x3}
C {/workspaces/usm-vlsi-tools/shared_xserver/Talleres/Taller1/Resuelto/Pmoslv_test.sym} -285 20 0 0 {name=x4}
