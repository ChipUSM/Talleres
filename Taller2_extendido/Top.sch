v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -630 -380 -630 -200 {}
L 4 -320 -380 -320 -200 {}
L 4 -630 -380 -320 -380 {}
L 4 -320 -200 -320 -170 {}
L 4 -630 -170 -320 -170 {}
L 4 -630 -210 -630 -170 {}
C {Insumos/NOT_TEST.sym} -500 -330 0 0 {name=x1}
C {Insumos/Transmision_Gate_Test.sym} -480 -280 0 0 {name=x2}
C {Insumos/cs_amp_full_IPD413HW1.sym} -500 -220 0 0 {name=X3}
C {title.sym} -620 -20 0 0 {name=l1 author="ChipUSM 2025"}
