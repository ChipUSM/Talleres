v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -190 -280 200 -280 {}
L 4 -190 -30 200 -30 {}
L 4 -190 80 200 80 {}
L 4 -190 -280 -190 80 {}
L 4 200 -30 200 80 {}
L 4 200 -280 200 -20 {}
T {¿¿Ya resolviste el taller??
Si no lo has resuelto favor volver al menú anterior} -210 -360 0 0 0.4 0.4 {}
C {/workspaces/usm-vlsi-tools/shared_xserver/Talleres/Taller2/Resuelto/Nand.sym} -20 -200 0 0 {name=x2}
C {/workspaces/usm-vlsi-tools/shared_xserver/Talleres/Taller2/Resuelto/nand_sim.sym} 20 20 0 0 {name=x3}
C {title.sym} -450 270 0 0 {name=l1 author="Solucionario Taller 2"}
