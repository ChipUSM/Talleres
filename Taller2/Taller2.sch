v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -130 -310 -130 -90 {}
L 4 -130 -190 170 -190 {}
L 4 170 -190 170 -90 {}
L 4 -130 -350 -130 -310 {}
L 4 170 -350 170 -190 {}
L 4 -130 -350 170 -350 {}
L 4 500 -350 500 -90 {}
L 4 170 -350 500 -350 {}
L 4 -130 -90 500 -90 {}
T {Acá está parte del solucionario,
en caso de que no puedan avanzar,
son libres de verlo} 195 -290 0 0 0.3 0.3 {}
C {title.sym} -30 20 0 0 {name=l1 author="Taller 2 - ChipUSM"}
C {Insumos/NOT_TEST.sym} 0 -130 0 0 {name=x2}
C {Insumos/NOT.sym} 10 -360 0 0 {name=x1}
C {Resuelto/Soluciones.sym} 350 -180 0 0 {name=x3}
